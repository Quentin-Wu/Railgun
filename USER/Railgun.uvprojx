# Keil uVision project Railgun.uvprojx, settings and files
target sum (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sum
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c misc: --c99
  c include: ..\USER;..\FWLIB;..\HARDWARE;..\USMART;..\HARDWARE\delay;..\HARDWARE\key;..\HARDWARE\led;..\HARDWARE\mypwm;..\HARDWARE\us_100;..\HARDWARE\myuart;..\HARDWARE\myqei;..\HARDWARE\mpu6050_chuan;..\HARDWARE\us_100;..\HARDWARE\xunji;..\HARDWARE\cesu;..\HARDWARE\moto_pid;..\HARDWARE\pid;..\HARDWARE\openmv;..\HARDWARE\launch;..\HARDWARE\duo_zhuan;..\HARDWARE\screen
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c startup_rvmdk.S control.c
  group HARDWARE
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/myuart/: myuart.c
    ../HARDWARE/mypwm/: mypwm.c
    ../HARDWARE/openmv/: openmv.c
    ../HARDWARE/launch/: launch.c
    ../HARDWARE/duo_zhuan/: duo_zhuan.c
    ../HARDWARE/screen/: screen.c
  group FWLIB
    ../FWLIB/driverlib/rvmdk/: driverlib.lib
    ../FWLIB/driverlib/: gpio.c sysctl.c uart.c timer.c pwm.c qei.c interrupt.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group ReadMe
    ./: PS.txt
